# Keil uVision project FN1002-RCM.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FN1002-RCM +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\RV31\INC;C:\Keil_v5\ARM\RL\USB\INC
  memory RVCT4: ROM 0x8004000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User Source
    ./User/: Application.c Button.c Command.c crc16.c IOBuffer.c LED.c main.c MessageProc.c Sensor.c Stepper.c USART.c USBD_STM32F103.c USBD_User_HID.c UserData.c
  group User Head
    ./User/: Application.h Button.h Command.h crc16.h errors.h IOBuffer.h LED.h MessageProc.h Sensor.h Stepper.h USART.h USB_Reg.h USBD_User_HID.h UserData.h
  group RTX Configuration
    ./User/: RTX_Conf_CM.c
  group USB Configuration
    ./User/: USB_Config.c
  group USB RTX Support
    ./User/: SVC_Table.s
  group External Library
    $TC_ROOT$/RV31/LIB/: USB_CM3.lib RTX_CM3.lib
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
